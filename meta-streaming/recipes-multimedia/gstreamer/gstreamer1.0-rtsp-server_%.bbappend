# Issue #8: Include gst-rtsp-server in the meta-streaming layer
# The recipe gstreamer1.0-rtsp-server is provided by poky/meta.
# This bbappend ensures the package is tracked as a meta-streaming dependency.
