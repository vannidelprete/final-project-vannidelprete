# Issue #13: Enable x264enc encoder for RTSP H.264 streaming
PACKAGECONFIG:append = " x264"
